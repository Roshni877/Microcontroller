	AREA LAB05,CODE,READONLY
START 
	LDR R0,MEMO
	LDR R4,RESULT
	LDRH R1,[R0]
	ADD R0,R0,#2
	LDRH R5,[R0]
	MOV R2,R1
LOOP 
	CMP R2,#1
	BEQ DONE 
	ADD R0,R0,#2
	LDRH R3,[R0]
	SUB R2,R2,#1
	CMP R5,R3
	BHI LOOP
	MOV R5,R3
	B LOOP
DONE STR R5,[R4]
HERE B HERE
	
	
MEMO 
	DCD 0X40000000
RESULT
	DCD 0X4000000C
    END